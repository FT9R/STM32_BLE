# IAR project E104-BT52_BLE.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C6 ST STM32F103C6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: Config; Include; Source; Libraries/Delay; Libraries/USART; Libraries/STM32F10x_StdPeriph_Driver/inc; Libraries/STM32F10x_StdPeriph_Driver/src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Config
    Config/: startup_stm32f10x_ld.s stm32f10x.h stm32f10x_conf.h Sys_Init.c Sys_Init.h system_stm32f10x.c system_stm32f10x.h
  group Include
    Include/: main.h
  group Libraries/Delay
    Libraries/Delay/: Delay.c Delay.h
  group Libraries/STM32F10x_StdPeriph_Driver/inc
    Libraries/STM32F10x_StdPeriph_Driver/inc/: stm32f10x_rcc.h stm32f10x_usart.h
  group Libraries/STM32F10x_StdPeriph_Driver/src
    Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_usart.c
  group Libraries/USART
    Libraries/USART/: USART.c USART.h
  group Source
    Source/: main.c
