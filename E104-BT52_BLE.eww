<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\E104-BT52_BLE.ewp</path>
    </project>
    <batchBuild />
</workspace>
